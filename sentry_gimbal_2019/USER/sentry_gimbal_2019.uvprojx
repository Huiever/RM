# Keil uVision project sentry_gimbal_2019.uvprojx, settings and files
target sentry_gimbal_2019 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Scu_Rm2018 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\include\bsp;..\include\main_task;..\include\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../: readme.txt
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group system
    ../src/system/: delay.c sys.c visualscope.c pid_regulator.c ramp.c flags.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_can.c stm32f4xx_spi.c fifo.h RMLib.lib
  group main_task
    ../src/main_task/: can_bus_task.c control_task.c remote_task.c judge_task.c
  group bsp
    ../src/bsp/: bsp.c beep.c key.c led.c can1.c can2.c dbus.c gun.c laser.c spi.c timer.c usart3.c usart6.c imu.c
